v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {RES_MIN.sym} 50 10 0 0 {name=R1
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 10 0 0 {name=R2
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 10 0 0 {name=R3
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 10 0 0 {name=R4
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 100 0 0 {name=R5
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 100 0 0 {name=R6
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 100 0 0 {name=R7
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 100 0 0 {name=R8
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 190 0 0 {name=R9
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 190 0 0 {name=R10
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 190 0 0 {name=R11
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 190 0 0 {name=R12
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 280 0 0 {name=R13
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 280 0 0 {name=R14
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 280 0 0 {name=R15
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 280 0 0 {name=R16
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 370 0 0 {name=R17
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 370 0 0 {name=R18
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 370 0 0 {name=R19
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 370 0 0 {name=R20
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 460 0 0 {name=R21
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 460 0 0 {name=R22
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 460 0 0 {name=R23
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 460 0 0 {name=R24
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 550 0 0 {name=R25
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 550 0 0 {name=R26
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 550 0 0 {name=R27
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 550 0 0 {name=R28
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 50 640 0 0 {name=R29
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 110 640 0 0 {name=R30
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 160 640 0 0 {name=R31
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 210 640 0 0 {name=R32
value=0.54k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 10 0 0 {name=R33
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 10 0 0 {name=R34
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 10 0 0 {name=R35
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 10 0 0 {name=R36
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 100 0 0 {name=R37
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 100 0 0 {name=R38
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 100 0 0 {name=R39
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 100 0 0 {name=R40
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 190 0 0 {name=R41
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 190 0 0 {name=R42
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 190 0 0 {name=R43
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 190 0 0 {name=R44
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 280 0 0 {name=R45
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 280 0 0 {name=R46
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 280 0 0 {name=R47
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 280 0 0 {name=R48
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 370 0 0 {name=R49
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 370 0 0 {name=R50
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 370 0 0 {name=R51
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 370 0 0 {name=R52
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 460 0 0 {name=R53
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 460 0 0 {name=R54
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 460 0 0 {name=R55
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 460 0 0 {name=R56
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 550 0 0 {name=R57
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 550 0 0 {name=R58
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 550 0 0 {name=R59
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 550 0 0 {name=R60
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 640 0 0 {name=R61
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 640 0 0 {name=R62
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 640 0 0 {name=R63
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 640 0 0 {name=R64
value=3.6k
footprint=1206
device=resistor
m=1}
